# Keil uVision project gpio_inout.uvprojx, settings and files
target QF_ZERO_V2 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_inout +hex
  c flags: oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\common;.\inc;.\lib;.\qf_lib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ./common/: base_types.h board_skhc32l110.h HC32L110.h system_hc32l110.h system_hc32l110.c
  group inc
    ./inc/: user.h devices.h tasks.h bat_task.h my_api.h rtc_task.h trans_task.h eeprom.h
  group src
    ./src/: eeprom.c tasks.c main.c devices.c bat_task.c my_api.c rtc_task.c trans_task.c
  group lib
    ./lib/: adc.c adc.h adt.c adt.h bt.c bt.h clk.c clk.h crc.c crc.h ddl.c ddl.h flash.c flash.h gpio.c gpio.h i2c.c i2c.h interrupts_hc32l110.c interrupts_hc32l110.h lpm.c lpm.h lpt.c lpt.h lpuart.c lpuart.h lvd.c lvd.h pca.c pca.h reset.c reset.h rtc.c rtc.h spi.c spi.h trim.c trim.h uart.c uart.h vc.c vc.h wdt.c wdt.h ddl_device.h
  group qf_lib
    ./qf_lib/: BMP280.c button.c cw2015.c myprintf.c Ticker.c WIRE.c BMP280.h button.h cw2015.h myprintf.h Ticker.h WIRE.h ring_buffer.c ring_buffer.h trans_packer.c trans_packer.h
software components: CMSIS:CORE 5.6.0
